# Keil uVision project FOC.uvprojx, settings and files
target FOC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: FOC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../UserCode/APP;../UserCode/Communication;../UserCode/BSP;../UserCode/Device;../UserCode/foc_lib/inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../UserCode/foc_lib/src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group UserCode/APP
    ../UserCode/APP/: app_comm.c app_motor.c app_motor.h
  group UserCode/Communication
    ../UserCode/Communication/: comm_uart.c comm_iic.c
  group UserCode/BSP
    ../UserCode/BSP/: bsp_usart.c bsp_iic.c
  group UserCode/Device
    ../UserCode/Device/: as5600.c
  group foc_lib
    ../UserCode/foc_lib/src/: field_weakening.c foc.c foc_math.c hfi.c smo.c user_foc_hal.c
    ../UserCode/foc_lib/inc/: field_weakening.h foc.h foc_config.h foc_hal.h foc_math.h foc_types.h foc_utils.h hfi.h smo.h
software components: CMSIS:CORE 4.3.0
